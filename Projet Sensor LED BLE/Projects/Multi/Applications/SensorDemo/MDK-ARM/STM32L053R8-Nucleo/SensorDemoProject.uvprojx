# Keil uVision project SensorDemoProject.uvprojx, settings and files
target SensDemo_L053R8_NUCLEO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SensorDemoProject +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L053xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER,
  c include: ..\..\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB04A1;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3;..\..\..\..\..\..\Drivers\BSP\IKS01A2;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../../Src/: bluenrg_interface.c clock.c cube_hal_l0.c stm32xx_it.c stm32l0xx_hal_msp.c main.c sensor_service.c nucleo_l053r8_bus.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32L053R8_NUCLEO
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB04A1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c ble_list.c osal.c
  group Drivers/BSP/X_NUCLE0_IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c x_nucleo_iks01a1.h x_nucleo_iks01a1_accelero.h x_nucleo_iks01a1_gyro.h x_nucleo_iks01a1_humidity.h x_nucleo_iks01a1_magneto.h x_nucleo_iks01a1_pressure.h x_nucleo_iks01a1_temperature.h
  group Drivers/BSP/Components/Common
    ../../../../../../Drivers/BSP/Components/Common/: accelerometer.h component.h gyroscope.h humidity.h magnetometer.h pressure.h sensor.h temperature.h env_sensor.h motion_sensor.h
  group Drivers/BSP/components/hts221
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver.h HTS221_Driver_HL.c HTS221_Driver_HL.h
  group Drivers/BSP/Components/lis3mdl
    ../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver.h LIS3MDL_MAG_driver_HL.c LIS3MDL_MAG_driver_HL.h
  group Drivers/BSP/Components/lps25hb
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver.h LPS25HB_Driver_HL.c LPS25HB_Driver_HL.h
  group Drivers/BSP/Components/lsm6ds0
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver.h LSM6DS0_ACC_GYRO_driver_HL.c LSM6DS0_ACC_GYRO_driver_HL.h
  group Drivers/BSP/Components/lsm6ds3
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver.h LSM6DS3_ACC_GYRO_driver_HL.c LSM6DS3_ACC_GYRO_driver_HL.h
  group Drivers/BSP/Components/lps22hb
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver.h LPS22HB_Driver_HL.c LPS22HB_Driver_HL.h
  group Drivers/BSP/IKS01A2
    ../../../../../../Drivers/BSP/IKS01A2/: iks01a2_motion_sensors.c iks01a2_motion_sensors_ex.c iks01a2_motion_sensors.h iks01a2_motion_sensors_ex.h
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c lsm6dsl_reg.c lsm6dsl.h lsm6dsl_reg.h
